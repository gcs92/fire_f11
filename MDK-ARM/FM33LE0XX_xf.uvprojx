# Keil uVision project FM33LE0XX_xf.uvprojx, settings and files
target FireContorl (ARM-ADS)
  device: FM33LE01X FMSH
  pack: FMSH.FM33LE0XX_DFP.0.0.4
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: F10 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: FM33LE0XX,USE_FULL_ASSERT
  c include: ..\Drivers\CMSIS\Inculde;..\Drivers\CMSIS\Device\FM\FM33xx\Include;..\MF-config\Inc;..\Inc;..\Drivers\FM33LE0xx_FL_Driver\Inc;..\User\led;..\User\timer;..\User\parameter;..\User\button;..\User\debug;..\User\i2c;..\User\system_control;..\User\production_test
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group MDK-ARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/ARM/: startup_fm33le0xx.s
  group MF-config
    ../MF-config/Src/: mf_config.c
  group Main
    ../Src/: main.c spi.c flash_api.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33le0xx.c
  group Drivers/FM33LE0xx_FL_Driver
    ../Drivers/FM33LE0xx_FL_Driver/Src/: fm33le0xx_fl.c fm33le0xx_fl_aes.c fm33le0xx_fl_atim.c fm33le0xx_fl_bstim32.c fm33le0xx_fl_comp.c fm33le0xx_fl_crc.c fm33le0xx_fl_divas.c fm33le0xx_fl_dma.c fm33le0xx_fl_exti.c fm33le0xx_fl_flash.c fm33le0xx_fl_gpio.c fm33le0xx_fl_gptim.c fm33le0xx_fl_i2c.c fm33le0xx_fl_iwdt.c fm33le0xx_fl_lcd.c fm33le0xx_fl_lptim32.c fm33le0xx_fl_lpuart.c fm33le0xx_fl_pmu.c fm33le0xx_fl_rcc.c fm33le0xx_fl_rng.c fm33le0xx_fl_rtc.c fm33le0xx_fl_spi.c fm33le0xx_fl_svd.c fm33le0xx_fl_u7816.c fm33le0xx_fl_uart.c fm33le0xx_fl_wwdt.c fm33le0xx_fl_i2csmb.c fm33le0xx_fl_adc.c
  group User
    ../User/led/: led.c
    ../User/timer/: timer.c
    ../User/parameter/: parameter.c
    ../User/button/: button_function.c
    ../User/debug/: debug.c
    ../User/i2c/: I2C.c
    ../User/system_control/: system_control.c
    ../User/production_test/: production_test.c
